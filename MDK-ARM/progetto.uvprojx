# Keil uVision project progetto.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: progetto
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ../: main.c Puls.c timer.c Led.c Mot.c SysClock.c Arduino.c Buzzer.h Buzzer.c eventGroupRullo.h
software components: RTOS:Config 10.4.3, RTOS:Core 10.4.3, RTOS:Coroutines 10.4.3, RTOS:Event Groups 10.4.3, RTOS:Heap 10.4.3, RTOS:Message Buffer 10.4.3, RTOS:Stream Buffer 10.4.3, RTOS:Timers 10.4.3, CMSIS:CORE 5.4.0, CMSIS:RTOS2:FreeRTOS 10.4.3, Device:Startup 1.3.1
